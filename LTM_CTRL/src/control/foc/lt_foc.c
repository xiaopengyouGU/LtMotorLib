/*
 * Change Logs:
 * Date           Author        Notes
 * 2026-9-24      Lvtou         纯定点 SVPWM 运算
 * 2026-9-24      Lvtou         内置 512 点全周期正弦表，去掉 lt_q15_sin_cos 调用
 */

#include "control/foc/lt_foc.h"
#include "math/basic/lt_math.h"
#include <string.h>

/*---------------------- FOC 对象定义 ----------------------*/
typedef struct {
    uint32_t reso;                /* 电角度单圈分辨率：一个电周期对应的 the 增量 */
    uint32_t step;                /* 预计算相位增量（Q16.16，每个计数），热路径只乘法 */
}lt_foc_object;

static lt_foc_object foc_obj;
static lt_foc_object *foc = &foc_obj;

/* 512 点全周期正弦表（Q15，32768 == 1.0）：i × 2π/512
 * 幅值限制在 ±32767（不取 -32768）：避免与 -1.0 相乘时的 int16 溢出
 * 多留一项 tab[512] = tab[0]，索引 i+1 不必取模 */
static const int16_t sine_table_512[513] = {
         0,    402,    804,   1206,   1608,   2009,   2411,   2811,   3212,   3612,   4011,   4410,   4808,   5205,   5602,   5998,
      6393,   6787,   7180,   7571,   7962,   8351,   8740,   9127,   9512,   9896,  10279,  10660,  11039,  11417,  11793,  12167,
     12540,  12910,  13279,  13646,  14010,  14373,  14733,  15091,  15447,  15800,  16151,  16500,  16846,  17190,  17531,  17869,
     18205,  18538,  18868,  19195,  19520,  19841,  20160,  20475,  20788,  21097,  21403,  21706,  22006,  22302,  22595,  22884,
     23170,  23453,  23732,  24008,  24279,  24548,  24812,  25073,  25330,  25583,  25833,  26078,  26320,  26557,  26791,  27020,
     27246,  27467,  27684,  27897,  28106,  28311,  28511,  28707,  28899,  29086,  29269,  29448,  29622,  29792,  29957,  30118,
     30274,  30425,  30572,  30715,  30853,  30986,  31114,  31238,  31357,  31471,  31581,  31686,  31786,  31881,  31972,  32058,
     32138,  32214,  32286,  32352,  32413,  32470,  32522,  32568,  32610,  32647,  32679,  32706,  32729,  32746,  32758,  32766,
     32767,  32766,  32758,  32746,  32729,  32706,  32679,  32647,  32610,  32568,  32522,  32470,  32413,  32352,  32286,  32214,
     32138,  32058,  31972,  31881,  31786,  31686,  31581,  31471,  31357,  31238,  31114,  30986,  30853,  30715,  30572,  30425,
     30274,  30118,  29957,  29792,  29622,  29448,  29269,  29086,  28899,  28707,  28511,  28311,  28106,  27897,  27684,  27467,
     27246,  27020,  26791,  26557,  26320,  26078,  25833,  25583,  25330,  25073,  24812,  24548,  24279,  24008,  23732,  23453,
     23170,  22884,  22595,  22302,  22006,  21706,  21403,  21097,  20788,  20475,  20160,  19841,  19520,  19195,  18868,  18538,
     18205,  17869,  17531,  17190,  16846,  16500,  16151,  15800,  15447,  15091,  14733,  14373,  14010,  13646,  13279,  12910,
     12540,  12167,  11793,  11417,  11039,  10660,  10279,   9896,   9512,   9127,   8740,   8351,   7962,   7571,   7180,   6787,
      6393,   5998,   5602,   5205,   4808,   4410,   4011,   3612,   3212,   2811,   2411,   2009,   1608,   1206,    804,    402,
         0,   -402,   -804,  -1206,  -1608,  -2009,  -2411,  -2811,  -3212,  -3612,  -4011,  -4410,  -4808,  -5205,  -5602,  -5998,
     -6393,  -6787,  -7180,  -7571,  -7962,  -8351,  -8740,  -9127,  -9512,  -9896, -10279, -10660, -11039, -11417, -11793, -12167,
    -12540, -12910, -13279, -13646, -14010, -14373, -14733, -15091, -15447, -15800, -16151, -16500, -16846, -17190, -17531, -17869,
    -18205, -18538, -18868, -19195, -19520, -19841, -20160, -20475, -20788, -21097, -21403, -21706, -22006, -22302, -22595, -22884,
    -23170, -23453, -23732, -24008, -24279, -24548, -24812, -25073, -25330, -25583, -25833, -26078, -26320, -26557, -26791, -27020,
    -27246, -27467, -27684, -27897, -28106, -28311, -28511, -28707, -28899, -29086, -29269, -29448, -29622, -29792, -29957, -30118,
    -30274, -30425, -30572, -30715, -30853, -30986, -31114, -31238, -31357, -31471, -31581, -31686, -31786, -31881, -31972, -32058,
    -32138, -32214, -32286, -32352, -32413, -32470, -32522, -32568, -32610, -32647, -32679, -32706, -32729, -32746, -32758, -32766,
    -32767, -32766, -32758, -32746, -32729, -32706, -32679, -32647, -32610, -32568, -32522, -32470, -32413, -32352, -32286, -32214,
    -32138, -32058, -31972, -31881, -31786, -31686, -31581, -31471, -31357, -31238, -31114, -30986, -30853, -30715, -30572, -30425,
    -30274, -30118, -29957, -29792, -29622, -29448, -29269, -29086, -28899, -28707, -28511, -28311, -28106, -27897, -27684, -27467,
    -27246, -27020, -26791, -26557, -26320, -26078, -25833, -25583, -25330, -25073, -24812, -24548, -24279, -24008, -23732, -23453,
    -23170, -22884, -22595, -22302, -22006, -21706, -21403, -21097, -20788, -20475, -20160, -19841, -19520, -19195, -18868, -18538,
    -18205, -17869, -17531, -17190, -16846, -16500, -16151, -15800, -15447, -15091, -14733, -14373, -14010, -13646, -13279, -12910,
    -12540, -12167, -11793, -11417, -11039, -10660, -10279,  -9896,  -9512,  -9127,  -8740,  -8351,  -7962,  -7571,  -7180,  -6787,
     -6393,  -5998,  -5602,  -5205,  -4808,  -4410,  -4011,  -3612,  -3212,  -2811,  -2411,  -2009,  -1608,  -1206,   -804,   -402,
         0,
};

/*---------------------- Q15 正余弦查表 ----------------------*/
/* 512 点全周期表 + 7 位线性插值：phase 为 16 位相位（65536 == 2π）
 * cos 用 sin 索引 + 128（90°）；无象限折叠、无取模、无函数调用 */
static inline void foc_sin_cos(uint16_t phase, int16_t *s, int16_t *c)
{
    uint16_t is   = (uint16_t)(phase >> 7);                  /* 0~511 */
    int32_t  frac = (int32_t)(phase & 0x7f);                 /* 0~127 */
    int32_t  t1 = sine_table_512[is];
    int32_t  t2 = sine_table_512[is + 1];                    /* tab[512] == tab[0]，免取模 */
    *s = (int16_t)(t1 + (((t2 - t1) * frac) >> 7));
    is = (uint16_t)((is + 128u) & 511u);                     /* cos 索引 = sin 索引 + 90° */
    t1 = sine_table_512[is];
    t2 = sine_table_512[is + 1];
    *c = (int16_t)(t1 + (((t2 - t1) * frac) >> 7));
}

/*---------------------- Q15 定点 SVPWM 辅助 ----------------------*/
/* 定点标度：32768 == 1.0（Q15）
 * FOC_Q15_SQRT3_2_I32 = √3/2 × 32768；FOC_Q15_HALF_I32 = 0.5 × 32768 */
#define FOC_Q15_SQRT3_2_I32     28378
#define FOC_Q15_HALF_I32        16384
#define FOC_Q15_ONE_I32         32768
#define FOC_Q15_MAX_I32         32767      /* Q15 能表示的上限（正弦表幅值）*/
/* 过调制 + 零矢量时间（Q15 版，32768 == 1.0）：T1+T2 > 1.0 时等比例缩小，并计算 T0/2 */
#define SVPWM_SCALE_T0_Q15(T1, T2, T0_half)                                       \
    do {                                                                          \
        int32_t _t_sum = (T1) + (T2);                                             \
        if (_t_sum > FOC_Q15_ONE_I32) {                                           \
            int32_t _t_inv = (int32_t)(((int32_t)FOC_Q15_ONE_I32 * FOC_Q15_ONE_I32) / _t_sum); \
            (T1) = (int32_t)(((int32_t)(T1) * _t_inv) >> 15);                     \
            (T2) = (int32_t)(((int32_t)(T2) * _t_inv) >> 15);                     \
            _t_sum = (T1) + (T2);                                                 \
        }                                                                         \
        (T0_half) = (FOC_Q15_ONE_I32 - _t_sum) >> 1;                              \
    } while (0)

/*---------------------- API 实现 ----------------------*/
/*==============================================================================
 * 初始化 FOC 对象（清零）：调用顺序 init -> set -> update
 *==============================================================================*/
void lt_foc_init(void)
{
    memset(foc, 0, sizeof(lt_foc_object));     /* reso/step 清零，update 就会直接返回 */
}

/*==============================================================================
 * 设置电角度单圈分辨率：一个电周期对应的 the 增量
 * the -> 相位的除法/取模在这里一次算完（冷路径），存成 Q16.16 相位增量
 * reso 为 2 的幂（16384、262144 …）时 step 精确，正/负 the、多圈 the 都无误差
 *==============================================================================*/
void lt_foc_set(uint32_t reso)
{
    if (reso == 0) return;                     /* 非法值保护 */
    foc->reso = reso;
    /* step = (65536 * 65536) / reso = 每个计数对应的相位增量
     * + (reso >> 1) 是除法四舍五入项（加半个除数），即 round(2^32 / reso)
     * 2 的幂时精确；否则累积舍入误差 < the/65536 个相位单位，多圈/负数宜先取模 */
    foc->step = (uint32_t)(((1ULL << 32) + (uint64_t)(reso >> 1)) / reso);
}

/*==============================================================================
 * 纯定点接口：输入 Q15 格式的 D/Q 轴电压指令（1.0 pu = Vdc/√3）和电角度计数
 * the：(单圈编码器原始计数 - 电角度零点偏置) × 极对数，可以加上延迟补偿量 
 * 相位 = the 先按 step 缩放到 0~65535（对应 0~2π），2^16 截断即自然回绕
 * 内部全程整数运算，热路径无除法、无取模、无浮点
 *==============================================================================*/
void lt_foc_update(int16_t Vd, int16_t Vq, uint32_t the, int32_t dutys[3])
{
    if (foc->reso == 0) return;                        /* 未设置分辨率，直接返回 */

    /* 相位 = the * step >> 16：1 条 MULS + 1 条移位，无除法、无取模
     * 只取 32 位乘积的 bits16~31，2^16 自然截断 == 65536（对应 2π）回绕
     * reso 为 2 的幂时 step 精确：正/负 the、多圈 the 都自动精确回绕 */
    uint16_t phase = (uint16_t)((the * foc->step) >> 16);

    /* 1) Q15 正余弦（与 lt_foc_clark_park 共用同一个 inline） */
    int16_t s, c;
    foc_sin_cos(phase, &s, &c);

    /* 2) Park 逆变换：Q30 乘积直接相加减，最后只移位一次
     *    （不拆回 int16，省掉 4 条符号扩展；精度也只舍入一次）
     *    |Vα| 上限 √2：Q30 累加最大 2*(32767*32768) = 2^31-65536，int32 不溢出 */
    int32_t V_alpha = (((int32_t)c * Vd) - ((int32_t)s * Vq)) >> 15;
    int32_t V_beta  = (((int32_t)s * Vd) + ((int32_t)c * Vq)) >> 15;

    /* 3) 扇区判定：三条判别线符号，无需 atan2
     * √3·Vα 用 √3/2 常数配 >>14，避免 |Vα| 接近 √2 时 int32 乘积溢出 */
    int32_t t  = (V_alpha * FOC_Q15_SQRT3_2_I32) >> 14;
    int32_t d2 =  t - V_beta;
    int32_t d3 = -t - V_beta;
    uint8_t sector;

    if (V_beta < 0) {
        if (d2 < 0)         sector = 4;   /* θ ∈ [180°, 240°) */
        else if (d3 < 0)    sector = 6;   /* θ ∈ [300°, 360°) */
        else                sector = 5;   /* θ ∈ [240°, 300°) */
    } else {
        if (d2 < 0)         sector = (d3 < 0) ? 2 : 3;  /* θ ∈ (60°,120°) / (120°,180°) */
        else                sector = 1;                 /* θ ∈ [0°, 60°] 或零矢量 */
    }

    /* 4) 先计算基向量投影，扇区里只做加减；1.0 pu = Vdc/√3 */
    int32_t va = (V_alpha * FOC_Q15_SQRT3_2_I32) >> 15;   /* Vα·√3/2 */
    int32_t hb = (V_beta  * FOC_Q15_HALF_I32)    >> 15;   /* Vβ/2 */
    int32_t T1, T2, T0_half;
    int32_t Ta, Tb, Tc;

    switch (sector)
    {
        case 1: {  /* sin60=√3/2 cos60=1/2；sin0=0 cos0=1 */
            T1 = va - hb;
            T2 = V_beta;
            SVPWM_SCALE_T0_Q15(T1, T2, T0_half);
            Ta = T1 + T2 + T0_half;
            Tb = T2 + T0_half;
            Tc = T0_half;
            break;
        }
        case 2: {  /* sin120=√3/2 cos120=-1/2；sin60=√3/2 cos60=1/2 */
            T1 = va + hb;
            T2 = hb - va;
            SVPWM_SCALE_T0_Q15(T1, T2, T0_half);
            Ta = T1 + T0_half;
            Tb = T1 + T2 + T0_half;
            Tc = T0_half;
            break;
        }
        case 3: {  /* sin180=0 cos180=-1；sin120=√3/2 cos120=-1/2 */
            T1 = V_beta;
            T2 = -hb - va;
            SVPWM_SCALE_T0_Q15(T1, T2, T0_half);
            Ta = T0_half;
            Tb = T1 + T2 + T0_half;
            Tc = T2 + T0_half;
            break;
        }
        case 4: {  /* sin240=-√3/2 cos240=-1/2；sin180=0 cos180=-1 */
            T1 = hb - va;
            T2 = -V_beta;
            SVPWM_SCALE_T0_Q15(T1, T2, T0_half);
            Ta = T0_half;
            Tb = T1 + T0_half;
            Tc = T1 + T2 + T0_half;
            break;
        }
        case 5: {  /* sin300=-√3/2 cos300=1/2；sin240=-√3/2 cos240=-1/2 */
            T1 = -va - hb;
            T2 = va - hb;
            SVPWM_SCALE_T0_Q15(T1, T2, T0_half);
            Ta = T2 + T0_half;
            Tb = T0_half;
            Tc = T1 + T2 + T0_half;
            break;
        }
        default: { /* 扇区 6：sin360=0 cos360=1；sin300=-√3/2 cos300=1/2 */
            T1 = -V_beta;
            T2 = hb + va;
            SVPWM_SCALE_T0_Q15(T1, T2, T0_half);
            Ta = T1 + T2 + T0_half;
            Tb = T0_half;
            Tc = T1 + T0_half;
            break;
        }
    }

    /* 5) 输出三相占空比：Ta/Tb/Tc 本身就在 [0,32768]，正好是 Q15 占空比（32768 = 100%）*/
    if (dutys) {
        dutys[0] = Ta;
        dutys[1] = Tb;
        dutys[2] = Tc;
    }
}

/*==============================================================================
 * 纯定点 Clarke + Park：三相 → d/q（lt_foc_update 的正变换）
 * fnum[3]：三相电流/电压，Q15 标幺（32767 = 1.0 pu）
 * angle  ：电角度计数，与 lt_foc_update 的 the 同一约定（共用 foc->step）
 * fd/fq  ：d/q 分量，Q15 标幺。
 * Clarke 天然抑制共模：三路共同偏置在 2a-b-c 里会抵消。
 *==============================================================================*/
void lt_foc_clark_park(int32_t fnum[3], uint32_t the, int32_t *fd, int32_t *fq)
{
    if (foc->reso == 0 || fnum == 0) return;            /* 未设置 / 空指针 */

    /* 与 lt_foc_update 逐位一致：phase = the * step >> 16 */
    uint16_t phase = (uint16_t)((the * foc->step) >> 16);

    int16_t s, c;
    foc_sin_cos(phase, &s, &c);

    /* Clarke（幅值不变）：fα = (2a-b-c)/3，fβ = (b-c)/√3
     * 1/3、1/√3 用 Q15 倒数乘，避免热路径除法（误差 < 4e-5）*/
    int32_t d2 = 2 * fnum[0] - fnum[1] - fnum[2];       /* |·| ≤ 3·32767 */
    int32_t d3 = fnum[1] - fnum[2];                     /* |·| ≤ 2·32767 */
    int32_t fa = (d2 * 10923) >> 15;                    /* 1/3  × 32768 */
    int32_t fb = (d3 * 18919) >> 15;                    /* 1/√3 × 32768 */
    /* 三相严重不平衡时 |iβ| 可到 1.15·32767，先夹住：
     * 既是物理上的输入越界保护，也保证下面 Park 的 Q30 累加不溢出 */
    fa = lt_clamp_i32(fa, FOC_Q15_MAX_I32, -FOC_Q15_MAX_I32);
    fb = lt_clamp_i32(fb, FOC_Q15_MAX_I32, -FOC_Q15_MAX_I32);

    /* Park 正变换：Q30 乘积直接相加减，最后只移位一次
     * |c|,|s| ≤ 32767、|fα|,|fβ| ≤ 32767 ⇒ 2·32767² < 2^31，int32 不溢出 */
    if (fd) *fd = ( c * fa + s * fb) >> 15;
    if (fq) *fq = (-s * fa + c * fb) >> 15;
    /* 不做输出饱和：|fd| ≤ |fαβ|，只有矢量模长超过 1.0 pu才可能越界，
     * 那种场合 FOC 输出已无意义，交给保护处理 */
}
