# Keil uVision project atk_g474.uvprojx, settings and files
target BLDC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_g474 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Drivers\BSP\ltmotorlib;..\..\Drivers\BSP\ltm_driver_stm32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
  group User
    ../../User/: main.c stm32g4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c
  group Readme
    ../../: readme.txt
  group LtMotorLib
    ../../Drivers/BSP/ltmotorlib/: lt_current.c lt_foc.c lt_math.c lt_pid.c lt_object.c lt_trape.c lt_driver.c lt_sensor.c lt_motor.c lt_commut.c
  group LtM_Driver_STM32
    ../../Drivers/BSP/ltm_driver_stm32/: drv_current.c drv_system.c drv_commut.c drv_timer.c drv_driver.c drv_sensor.c drv_debug.c drv_motor.c
